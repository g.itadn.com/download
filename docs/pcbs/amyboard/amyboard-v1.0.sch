# EAGLE board amyboard-v1.0 (EAGLE 6.1)

Size 110.9 x 48 mm. Coordinates in mm from the lower left corner, seen from the top.
Outline: 4.9,0 110.9,0 110.9,48 4.9,48 4.9,0
Outline: circle at 7.44,45.47 radius 1.37
Outline: circle at 7.44,2.54 radius 1.44
Outline: circle at 108.35,2.54 radius 1.37
Outline: circle at 108.35,45.47 radius 1.37
Copper layers (1*16): Top 0.035mm / dielectric 1.5mm / Bottom 0.035mm
Design rules: minimum track width 6mil, minimum drill 0.3mm, track to track 6mil, track to pad 6mil, pad to pad 6mil, via to via 6mil, smd to smd 6mil, copper to edge 10mil, drill to drill 1mil, minimum pad ring 3mil, minimum via ring 3mil, stop-mask expansion 4mil, vias tented up to drill 0mil, thermal gap 10mil
Net classes: 0 default: width 0.152 mm, drill 0.305 mm, clearance 0.152 mm

## Footprints (pad centres in the part's own frame; a part is rotated, then mirrored left to right if it is on the bottom)
SW_218-4LPSTR = smd 1.27 x 0.76: 1 -3.81,1.905; 2 -3.81,0.635; 3 -3.81,-0.635; 4 -3.81,-1.905; 5 3.81,-1.905; 6 3.81,-0.635; 7 3.81,0.635; 8 3.81,1.905
2*4*3.5MM = smd 1.15 x 1.3: 1 -1.675,0; 2 1.675,0 | smd 0.9 x 1.2: 3 2.3,1.55; 4 -2.3,1.55
DISCRETE_C0402 = smd 0.635 x 0.635: 1 -0.445,0; 2 0.445,0
SMC_Z = smd 1 x 1.2: + -1,0; - 1,0
C0603 = smd 0.889 x 0.889: 1 0,0.762; 2 0,-0.762
DISCRETE_C0603 = smd 0.889 x 0.889: 1 -0.762,0; 2 0.762,0
0603 = smd 0.889 x 0.889: 1 -0.762,0; 2 0.762,0
NV-PJ3410_SOCKET = drill 0.33 pad 1.93 long: GND 3.69,0; LEFT/TIP 0,-4.49; RIGHT/RING 0,3.459; SWITCH -3.674,0
DO-214AC = smd 1.8 x 2.4: A 2.025,0; C -2.025,0
SOT363 = smd 0.5 x 0.5: 1 -0.75,-0.9; 3 0.75,-0.9; 4 0.75,0.9; 6 -0.75,0.9 | smd 0.4 x 0.5: 2 0,-0.9; 5 0,0.9
SOD323 = smd 1 x 0.8: + -1.2,0; - 1.2,0
R0805 = smd 1.3 x 1.5: 1 -0.95,0; 2 0.95,0
2X6 = drill 1.016 pad 1.88: 1 0,0; 2 0,2.54; 3 2.54,0; 4 2.54,2.54; 5 5.08,0; 6 5.08,2.54; 7 7.62,0; 8 7.62,2.54; 9 10.16,0; 10 10.16,2.54; 11 12.7,0; 12 12.7,2.54
HW4-SMD-2.0-90D = smd 1.01 x 2.74: 1 -3,-0.1; 2 -1,-0.1; 3 1,-0.1; 4 3,-0.1 | smd 1.5 x 3: SS1 -5.4,7.4; SS2 5.4,7.4
CR54 = smd 4.2 x 1.4: P$1 0,1.85; P$2 0,-1.85
AMPHENOL_52601-G10-8LF = smd 1.27 x 3.18: 01 -5.08,-2.73; 02 -5.08,2.73; 03 -2.54,-2.73; 04 -2.54,2.73; 05 0,-2.73; 06 0,2.73; 07 2.54,-2.73; 08 2.54,2.73; 09 5.08,-2.73; 10 5.08,2.73
PW20_TEX = smd 1.473 x 0.356: 1 -2.921,2.925; 2 -2.921,2.275; 3 -2.921,1.625; 4 -2.921,0.975; 5 -2.921,0.325; 6 -2.921,-0.325; 7 -2.921,-0.975; 8 -2.921,-1.625; 9 -2.921,-2.275; 10 -2.921,-2.925; 11 2.921,-2.925; 12 2.921,-2.275; 13 2.921,-1.625; 14 2.921,-0.975; 15 2.921,-0.325; 16 2.921,0.325; 17 2.921,0.975; 18 2.921,1.625; 19 2.921,2.275; 20 2.921,2.925
SOT23-3 = smd 0.8 x 0.9: 1 -0.95,-1; 2 0.95,-1; 3 0,1.1
SOT23 = smd 1.016 x 1.143: 1 -0.95,-1.016; 2 0.95,-1.016; 3 0,1.016
DISCRETE_R0402 = smd 0.635 x 0.635: 1 -0.445,0; 2 0.445,0
DISCRETE_R0603 = smd 0.889 x 0.889: 1 -0.762,0; 2 0.762,0
9P-SMD-W/-RING = smd 1.524 x 0.762: 1 0,4.4; 2 0,3.3; 3 0,2.2; 4 0,1.1; 5 0,0; 6 0,-1.1; 7 0,-2.2; 8 0,-3.3; 9 0,-4.4 | smd 1.524 x 1.016: G1 0.6,-5.746 | smd 2.032 x 1.524: G2 10.373,-5.4; G3 10.373,10 | smd 1.524 x 1.524: G4 0.392,9.181 | hole 0.889: 10.9,-2.6; 10.9,5.4
QFP50P900X900X160-48N = smd 1.56 x 0.28: 1 -4.18,2.75; 2 -4.18,2.25; 3 -4.18,1.75; 4 -4.18,1.25; 5 -4.18,0.75; 6 -4.18,0.25; 7 -4.18,-0.25; 8 -4.18,-0.75; 9 -4.18,-1.25; 10 -4.18,-1.75; 11 -4.18,-2.25; 12 -4.18,-2.75; 25 4.18,-2.75; 26 4.18,-2.25; 27 4.18,-1.75; 28 4.18,-1.25; 29 4.18,-0.75; 30 4.18,-0.25; 31 4.18,0.25; 32 4.18,0.75; 33 4.18,1.25; 34 4.18,1.75; 35 4.18,2.25; 36 4.18,2.75 | smd 0.28 x 1.56: 13 -2.75,-4.18; 14 -2.25,-4.18; 15 -1.75,-4.18; 16 -1.25,-4.18; 17 -0.75,-4.18; 18 -0.25,-4.18; 19 0.25,-4.18; 20 0.75,-4.18; 21 1.25,-4.18; 22 1.75,-4.18; 23 2.25,-4.18; 24 2.75,-4.18; 37 2.75,4.18; 38 2.25,4.18; 39 1.75,4.18; 40 1.25,4.18; 41 0.75,4.18; 42 0.25,4.18; 43 -0.25,4.18; 44 -0.75,4.18; 45 -1.25,4.18; 46 -1.75,4.18; 47 -2.25,4.18; 48 -2.75,4.18
ESP32-­S2-­SOLO = smd 1.5 x 0.9: 1 -8.75,5.26; 2 -8.75,3.99; 3 -8.75,2.72; 4 -8.75,1.45; 5 -8.75,0.18; 6 -8.75,-1.09; 7 -8.75,-2.36; 8 -8.75,-3.63; 9 -8.75,-4.9; 10 -8.75,-6.17; 11 -8.75,-7.44; 12 -8.75,-8.71; 13 -8.75,-9.98; 14 -8.75,-11.25; 27 8.75,-11.25; 28 8.75,-9.98; 29 8.75,-8.71; 30 8.75,-7.44; 31 8.75,-6.17; 32 8.75,-4.9; 33 8.75,-3.63; 34 8.75,-2.36; 35 8.75,-1.09; 36 8.75,0.18; 37 8.75,1.45; 38 8.75,2.72; 39 8.75,3.99; 40 8.75,5.26 | smd 0.9 x 1.5: 15 -6.985,-12.5; 16 -5.715,-12.5; 17 -4.445,-12.5; 18 -3.175,-12.5; 19 -1.905,-12.5; 20 -0.635,-12.5; 21 0.635,-12.5; 22 1.905,-12.5; 23 3.175,-12.5; 24 4.445,-12.5; 25 5.715,-12.5; 26 6.985,-12.5 | smd 3.7 x 3.7: 41 -1.5,-2.46
SOT-23-6 = smd 1 x 0.6: 1 -1.2,0.95; 2 -1.2,0; 3 -1.2,-0.95; 4 1.2,-0.95; 5 1.2,0; 6 1.2,0.95
SOIC127P600X175-14N = smd 1.97 x 0.6: 1 -2.475,3.81; 2 -2.475,2.54; 3 -2.475,1.27; 4 -2.475,0; 5 -2.475,-1.27; 6 -2.475,-2.54; 7 -2.475,-3.81; 8 2.475,-3.81; 9 2.475,-2.54; 10 2.475,-1.27; 11 2.475,0; 12 2.475,1.27; 13 2.475,2.54; 14 2.475,3.81
SOIC-10 = smd 0.6 x 2.2: 1 -2.54,-2.6; 2 -1.27,-2.6; 3 0,-2.6; 4 1.27,-2.6; 5 2.54,-2.6; 6 2.54,2.6; 7 1.27,2.6; 8 0,2.6; 9 -1.27,2.6; 10 -2.54,2.6
SOP-6-2.54MM = smd 1.6 x 1.8: 1 -4.5,2.54; 2 -4.5,0; 3 -4.5,-2.54; 4 4.5,-2.54; 5 4.5,0; 6 4.5,2.54
SOT23-5 = smd 0.69 x 1.2: 1 -0.95,-1.3; 2 0,-1.3; 3 0.95,-1.3; 4 0.95,1.3; 5 -0.95,1.3
USB-C-16P-5 = smd 0.3 x 1: A5 -1.25,-0.34; A6 -0.25,-0.34; A7 0.25,-0.34; A8 1.25,-0.34; B5 1.75,-0.34; B6 0.75,-0.34; B7 -0.75,-0.34; B8 -1.75,-0.34 | smd 0.6 x 1: GND -3.225,-0.34; GND2 3.225,-0.34; VBUS1 -2.45,-0.34; VBUS2 2.45,-0.34 | smd 1 x 2.1: SHLD1 -4.32,-0.915; SHLD2 4.32,-0.915 | smd 1 x 2.1 bottom: SHLD3 -4.32,-0.915; SHLD4 4.32,-0.915 | smd 1 x 1.6: SHLD5 -4.32,-5.095; SHLD8 4.32,-5.095 | smd 1 x 1.6 bottom: SHLD6 -4.32,-5.095; SHLD7 4.32,-5.095 | hole 0.65: -2.89,-1.445; 2.89,-1.445
XTAL_ABM10W-22.5792MHZ-8-K1Z-T3 = smd 0.85 x 1.2: 1 -0.6,0.812; 2 -0.6,-0.812; 3 0.6,-0.812; 4 0.6,0.812

## Placement (x,y rotation side)
1-10VPP  218-4LPSTR  [SW_218-4LPSTR]  29.48,3.94 180 top
BOOT  TS24CA  [2*4*3.5MM]  102,2.9 180 top
C1  100nF  [DISCRETE_C0402]  28.9,23.06 90 top
C2  10uF/10V/TAN  [SMC_Z]  40.99,11.99 180 top
C3  10uF/10V/TAN  [SMC_Z]  40.99,10.59 180 top
C4  100nF  [DISCRETE_C0402]  39.37,14.43 0 top
C5  100nF  [DISCRETE_C0402]  39.72,17.96 0 top
C6  68nF  [DISCRETE_C0402]  24.4,15.72 0 top
C7  100nF  [DISCRETE_C0402]  25.88,14.15 270 top
C8  10uF/10V/TAN  [SMC_Z]  24.07,13.56 270 top
C9  1nF  [DISCRETE_C0402]  6.52,20.5 180 top
C10  1nF  [DISCRETE_C0402]  6.52,22.68 180 top
C11  100nF  [DISCRETE_C0402]  23.95,18.11 90 top
C12  10uF/10V/TAN  [SMC_Z]  21.94,18.77 90 top
C13  100nF  [DISCRETE_C0402]  26.28,12.62 180 top
C14  10uF/10V/TAN  [SMC_Z]  20.29,16.66 270 top
C15  100nF  [DISCRETE_C0402]  41.57,14.48 180 top
C16  10uF/10V/TAN  [SMC_Z]  25.78,11.23 180 top
C17  4.7nF  [DISCRETE_C0402]  25.9,16.15 270 top
C18  10pF  [DISCRETE_C0402]  24.4,23.04 180 top
C19  10pF  [DISCRETE_C0402]  26.03,20.5 270 top
C20  100nF  [DISCRETE_C0402]  63.34,26.01 0 top
C21  22uF  [C0603]  74.59,17.02 0 top
C22  10uF/10V/TAN  [SMC_Z]  55.6,11.94 270 top
C23  100nF  [DISCRETE_C0402]  49.4,24.05 90 top
C24  100nF  [DISCRETE_C0402]  49.63,21.18 90 top
C25  100nF  [DISCRETE_C0402]  59.71,23.67 90 top
C26  100nF  [DISCRETE_C0402]  50.52,23.16 270 top
C27  22uF  [C0603]  63.01,24.59 270 top
C28  100nF  [DISCRETE_C0402]  81.94,17.78 180 top
C29  22pF  [C0603]  71.67,18.21 270 top
C30  22uF  [C0603]  67.2,20.02 270 top
C31  22uF  [C0603]  61.69,14.96 180 top
C32  22pF  [DISCRETE_C0402]  75.05,22.38 180 top
C33  100nF  [DISCRETE_C0402]  85.42,33.63 270 top
C34  10uF  [DISCRETE_C0603]  65.73,38.28 270 top
C35  100nF  [DISCRETE_C0402]  8.96,19.81 270 top
C36  100nF  [DISCRETE_C0402]  100.35,25.35 0 top
C37  100nF  [DISCRETE_C0402]  86.61,33.63 270 top
C38  10uF  [DISCRETE_C0603]  30.27,23.6 90 top
C39  10uF  [DISCRETE_C0603]  89.38,31.7 90 top
C40  100nF  [DISCRETE_C0402]  84.25,33.63 90 top
C41  100nF  [DISCRETE_C0402]  41.55,13.39 0 top
C42  10uF/10V/TAN  [SMC_Z]  37.61,25.15 270 top
C43  10uF/10V/TAN  [SMC_Z]  28.52,9.27 0 top
C44  10uF/10V/TAN  [SMC_Z]  32.43,9.25 180 top
C45  10uF/10V/TAN  [SMC_Z]  53.59,11.91 270 top
C46  100nF  [DISCRETE_C0402]  25.88,18.11 90 top
C47  100nF  [DISCRETE_C0402]  52.04,17.4 90 top
C48  2.2uF  [DISCRETE_C0402]  51.94,13.39 90 top
C49  2.2uF  [DISCRETE_C0402]  47.9,10.79 180 top
C50  2.2nF  [DISCRETE_C0402]  55.24,14.76 180 top
C51  2.2nF  [DISCRETE_C0402]  55.24,15.85 180 top
C52  100nF  [DISCRETE_C0402]  64.46,37.97 270 top
C85  10uF  [DISCRETE_C0603]  67.23,38.28 270 top
C106  4.7uF/16V  [0603]  86.43,29.57 90 top
C107  10uF  [0603]  31.82,23.6 90 top
CV_IN1  NV-PJ3410_STEREO  [NV-PJ3410_SOCKET]  14.4,33 270 bottom
CV_IN2  NV-PJ3410_STEREO  [NV-PJ3410_SOCKET]  25.4,33 270 bottom
CV_OUT1  NV-PJ3410_STEREO  [NV-PJ3410_SOCKET]  14.4,42.7 270 bottom
CV_OUT2  NV-PJ3410_STEREO  [NV-PJ3410_SOCKET]  25.4,42.7 270 bottom
D1  SS54  [DO-214AC]  70.94,32.21 0 top
D2  SS54  [DO-214AC]  77.14,35.28 0 top
D3  SS54  [DO-214AC]  66.29,33.48 90 top
D4  SS54  [DO-214AC]  77.14,32.21 180 top
D5  SS54  [DO-214AC]  66.29,27.36 90 top
D6  SS54  [DO-214AC]  81.48,21.72 90 top
D8  SS54  [DO-214AC]  65.81,22.38 0 top
D9  SS54  [DO-214AC]  66.92,15.9 90 top
D10  SS54  [DO-214AC]  64,17.73 270 top
D12  SMF05C  [SOT363]  91.94,33.35 180 top
D13  1N4148WS  [SOD323]  22.32,24.97 270 top
D14  SS54  [DO-214AC]  70.94,35.28 180 top
FB1  100Mhz@120R  [R0805]  61.64,21.18 90 top
FB2  100Mhz@120R  [R0805]  46.93,21.89 270 top
FB3  100Mhz@120R  [R0805]  68.85,38.43 270 top
FB4  100Mhz@120R  [R0805]  72.44,14.55 270 top
HOST  2X6 FEMALE  [2X6]  65.63,4.62 0 top
I2C_CONTROL  [HW4-SMD-2.0-90D]  87.24,38.71 0 top
I2C_HOST  [HW4-SMD-2.0-90D]  10.79,10.34 90 bottom
L1  4.7µH/±30%/3.4A  [CR54]  77.14,27.3 90 top
L3  3.3µH/±30%/3.4A  [CR54]  70.94,27.3 0 top
LINE_IN  NV-PJ3410_STEREO  [NV-PJ3410_SOCKET]  58.4,33 270 bottom
LINE_OUT  NV-PJ3410_STEREO  [NV-PJ3410_SOCKET]  58.4,42.7 270 bottom
MIDI_IN  NV-PJ3410_STEREO  [NV-PJ3410_SOCKET]  36.4,33 270 bottom
MIDI_OUT  NV-PJ3410_STEREO  [NV-PJ3410_SOCKET]  36.4,42.7 270 bottom
MODULAR_PSU  52601-G10-8LF  [AMPHENOL_52601-G10-8LF]  51.58,5.11 0 top
PCM5101  U11  [PW20_TEX]  47.06,15.01 180 top
Q1  AO3407  [SOT23-3]  81.99,33.91 0 top
Q2  S8050  [SOT23]  91.11,2.87 270 top
Q5  S8050  [SOT23]  84.96,2.87 90 top
R1  51K  [DISCRETE_R0402]  31.75,7.92 0 top
R2  51K  [DISCRETE_R0402]  29.13,8.08 180 top
R3  150R  [DISCRETE_R0402]  39.37,13.36 180 top
R4  680R  [DISCRETE_R0402]  22.88,16.15 90 top
R5  30K  [DISCRETE_R0402]  6.95,25.3 90 top
R6  10K  [DISCRETE_R0402]  8.5,22.68 0 top
R7  30K  [DISCRETE_R0402]  6.98,18.92 270 top
R8  15K  [DISCRETE_R0402]  6.52,23.72 0 top
R9  10K  [DISCRETE_R0402]  88.13,1.93 0 top
R10  30K  [DISCRETE_R0402]  50.69,20.14 90 top
R11  100K  [DISCRETE_R0402]  81.05,31.22 90 top
R12  10K  [DISCRETE_R0402]  54.17,17.37 270 top
R13  10K  [DISCRETE_R0402]  53.11,17.4 270 top
R14  100K  [DISCRETE_R0402]  74.39,20.83 270 top
R15  0R  [DISCRETE_R0402]  77.85,18.24 90 top
R16  0R  [DISCRETE_R0402]  72.28,19.56 180 top
R18  12K  [DISCRETE_R0402]  69.95,19.56 180 top
R19  228K  [DISCRETE_R0402]  72,16.87 180 top
R20  10K  [DISCRETE_R0402]  8.5,21.56 0 top
R21  15K  [DISCRETE_R0402]  6.52,21.56 0 top
R22  51K  [DISCRETE_R0402]  59.35,20.07 90 top
R23  100K  [DISCRETE_R0402]  75.48,20.83 270 top
R25  22K  [DISCRETE_R0402]  23.59,2.06 0 top
R26  22K  [DISCRETE_R0402]  23.59,3.3 0 top
R27  30K  [DISCRETE_R0402]  50.16,26.59 270 top
R28  51K  [DISCRETE_R0402]  59.71,26.37 270 top
R29  22K  [DISCRETE_R0402]  23.59,4.57 0 top
R30  22K  [DISCRETE_R0402]  23.59,5.84 0 top
R33  110K  [DISCRETE_R0402]  75.05,23.57 0 top
R34  15K  [DISCRETE_R0402]  77.31,23.62 0 top
R35  470R  [DISCRETE_R0402]  8.55,25.1 0 top
R36  220R  [DISCRETE_R0402]  23.77,25.07 270 top
R37  10R  [DISCRETE_R0402]  83.69,12.73 0 top
R38  33R  [DISCRETE_R0402]  8.55,26.19 180 top
R39  10K  [DISCRETE_R0402]  92.25,36.53 180 top
R40  10K  [DISCRETE_R0402]  92.25,35.46 180 top
R41  10K  [DISCRETE_R0402]  89.68,34.7 90 top
R42  10K  [DISCRETE_R0402]  91.64,30.2 180 top
R43  10K  [DISCRETE_R0402]  91.64,29.11 180 top
R44  NC  [DISCRETE_R0402]  91.64,31.27 180 top
R45  51R  [DISCRETE_R0402]  72.44,39.07 270 top
R46  51R  [DISCRETE_R0402]  71.39,39.09 270 top
R47  10K  [DISCRETE_R0402]  101.24,26.47 0 top
R48  10K  [DISCRETE_R0402]  88.08,3.84 180 top
R49  10K  [DISCRETE_R0402]  82.57,2.44 270 top
R50  470R  [DISCRETE_R0402]  53.31,15.85 180 top
R51  470R  [DISCRETE_R0402]  52.98,14.81 180 top
R52  5.1K  [DISCRETE_R0402]  70.33,39.12 270 top
R53  5.1K  [DISCRETE_R0402]  73.45,39.04 270 top
R80  0R  [DISCRETE_R0603]  23.92,8 0 top
RST  TS24CA  [2*4*3.5MM]  95.83,2.88 180 top
SD1  SD  [9P-SMD-W/-RING]  95.88,32.84 0 top
SPDIF_IN  NV-PJ3410_STEREO  [NV-PJ3410_SOCKET]  47.4,33 270 bottom
SPDIF_OUT  NV-PJ3410_STEREO  [NV-PJ3410_SOCKET]  47.4,42.7 270 bottom
U1  PCM9211PT  [QFP50P900X900X160-48N]  33.07,16.21 90 top
U2  ESP32­S2­SOLO  [ESP32-­S2-­SOLO]  98.06,14.63 270 top
U3  HX3608  [SOT-23-6]  77.85,21.16 270 top
U4  TL074CD  [SOIC127P600X175-14N]  55.01,23.24 0 top
U6  HX3608  [SOT-23-6]  71.6,22.02 0 top
U7  GP8413  [SOIC-10]  42.24,23.55 0 top
U15  H11L1SR2M  [SOP-6-2.54MM]  15.16,22.81 180 top
U16  SPX3819  [SOT23-5]  83.89,30.12 0 top
USB  USB-C  [USB-C-16P-5]  71.85,41.43 180 top
Y1  22.5792MHZ  [XTAL_ABM10W-22.5792MHZ-8-K1Z-T3]  24.25,20.88 0 top

## Tracks (layer width: path | path; a pad name or v marks a point on that pad's centre or on a via)
3.3V
  Top 0.254: U15.6 8.97,20.27 C35.1 8.96,21.55 R20.2 R6.2 8.95,23.56 8.12,24.38 8.12,25.08 R35.1 R38.2
3V3_IN
  Top 0.305: D2.A 79.43,35.01 Q1.3 86.59,35.01 88.23,36.65 88.23,38.6 I2C_CONTROL.3
5V  (via drill 0.3)  (1 unrouted)
  Top 0.254: U1.46 27.68,14.46 27.12,13.89 27.12,12.95 26.74,12.57 | FB4.2 71.26,13.6 v71.24,13.59 v71.24,10.9 | C13.1 26.73,11.27 C16.+ 26.13,11.23 v25.8,11.56
  Bottom 0.254: v71.24,13.59 58.85,13.59 58.29,13.03 37.69,13.03 36.19,11.53 v25.8,11.56 | HOST.12 78.33,9.47 77.64,10.16 71.98,10.16 v71.24,10.9
5V_IN
  Top 0.305: C34.2 C85.2 67.26,37.48 FB3.2 68.85,35.34 D14.A | C34.2 65.73,36.06 D3.A | C52.2 C34.2
12_IN  (via drill 0.3)
  Top 0.254: v74.04,30.73 74.01,30.76 74.01,32.21
  Top 0.305: D1.A 74.01,32.21 D4.A | MODULAR_PSU.09 v56.66,5.44 MODULAR_PSU.10 | v60.83,5.92 60.83,16.61 61.41,17.2 v61.44,18.47
  Bottom 0.254: v61.44,18.47 71.17,30.73 v74.04,30.73
  Bottom 0.305: v56.66,5.44 60.65,5.41 v60.83,5.92
12V  (via drill 0.3)
  Top 0.254: FB2.1 48.52,22.84 v48.53,22.84 | 63.78,23.96 63.77,23.97 C27.1 | D8.C 63.77,22.5 | 63.77,22.5 63.77,24.74 | v65.73,22.48 63.8,22.48 63.77,22.5 | 63.77,22.5 63.67,22.61 63.67,22.81 63.7,22.84 63.7,23.29 63.52,23.11 63.52,22.73 63.55,22.71 63.55,22.61 63.7,22.45 63.72,22.45 63.95,22.23 63.95,22 63.93,22.02 63.72,22.02 63.62,22.12 63.62,22.4 63.9,22.68 63.9,22.81 64.08,22.99 64.08,23.01 63.75,23.34 63.75,24.77
  Top 0.305: C32.2 v74.61,22.96 R33.1 | 72.45,17.68 R19.1 72.44,16.85 FB4.1 | 72.45,17.68 72.45,18.2 C29.1 72.73,18.5 R16.1 v73.43,19.56 | D8.C 63.78,23.96 | 72.45,17.68 72.55,17.78 C21.1 77.83,17.78 R15.1 81.48,17.79 | D6.C 81.48,17.79 | 81.48,17.79 C28.2 | v55.8,27.94 63.22,27.96 63.8,27.38 63.8,26.02 C20.2 C27.1
  Bottom 0.254: v65.73,22.48 66.21,22.96 v74.61,22.96 | v48.53,22.84 49.12,22.84 54.22,27.94 v55.8,27.94
  Bottom 0.305: v73.43,19.56 73.43,21.78 v74.61,22.96
+3V3  (via drill 0.3)  (4 unrouted)
  Top 0.254: 22.05,17.67 C11.1 C46.1 27.09,16.45 U1.42 29.71,16.46 30.15,16.03 31.62,16.03 31.95,16.36 | 22.05,17.67 C12.+ | U1.36 30.32,22.79 C38.1 C107.1 30.25,22.84 30.2,22.89 | C5.1 U1.22 32.45,17.95 31.97,18.43 | PCM5101.20 45.79,12.09 | 45.79,12.09 46.07,12.09 46.4,12.42 46.4,13.87 | 46.4,13.87 46.25,14.02 44.16,14.02 PCM5101.17 42.46,14.04 C15.1 42.46,14.48 v42.72,14.66 | 46.4,13.87 46.4,14.99 48.05,16.64 PCM5101.8 52.03,16.64 C47.1 R13.2 R12.2 | 54.42,12.09 PCM5101.1 49.98,11.28 v49.96,11.25 | 22.05,17.67 C14.+ 19.18,17.66 v12.87,11.35 | v45.79,11.25 45.79,12.09 | C3.+ 43.45,10.59 44.19,11.33 44.19,12.04 PCM5101.20 | C22.+ 55.6,12.37 55.32,12.09 | 55.32,12.09 54.42,12.09 | 54.42,12.09 C45.+ | 55.32,12.09 55.37,12.09 55.6,11.86 | 31.82,22.86 31.32,22.36 U1.34 31.32,19.09 31.5,18.91 31.97,18.43 | v31.97,16.41 31.97,18.43
  Top 0.305: R40.2 R39.2 | R40.2 90.33,35.46 R41.2 89.14,35.14 88.67,34.67 88.67,33.2 88.65,33.19 | U16.5 Q1.2 83.21,33.19 C40.1 C33.2 C37.2 88.65,33.19 | 88.65,33.19 C39.2 D12.4 R44.2 R42.2 R43.2 | SD1.4 v97.25,33.93 99.28,33.93 101.68,31.53 R47.2 102.05,26.1 U2.2 v102.05,22.07 | HOST.2 66.9,5.89 69.44,5.89 HOST.5 73.34,1.99 R49.2 83.19,1.99 v83.28,1.98 | R40.2 v91.07,36.2 v91.05,36.2
  Bottom 0.254: v12.87,11.35 10.71,11.35 I2C_HOST.3 | v49.96,11.25 v45.79,11.25 | v42.72,14.66 36.9,14.68 35.38,13.16 33.04,13.16 32.35,13.84 32.35,16.03 v31.97,16.41 | v55.52,11.91 63.57,11.91 64.56,10.92
  Bottom 0.305: v91.05,36.2 96.24,36.2 97.25,35.18 v97.25,33.93 | v83.28,1.98 93.8,1.98 102.05,10.24 v102.05,22.07 | HOST.2 65.63,9.86 64.56,10.92 64.54,10.95
+12V
  Top 0.254: U7.5 FB2.2 47.76,20.95 49.55,22.73 50.5,22.73 C26.2 50.53,22.73 51.07,22.73 51.58,23.24 U4.4
-12V
  Top 0.254: U4.11 C25.1 60.34,23.23 FB1.2
ADC1  (via drill 0.3)  (1 unrouted)
  Top 0.254: R6.1 C10.1 6.97,23.22 | 6.97,23.22 R8.2 | R8.2 6.95,23.74 R5.1 | U2.9 93.16,20.52 92.83,20.19 v88.29,20.19 | 6.99,23.24 6.97,23.22 | 7.54,23.55 7.15,23.55 7.08,23.61 | 7.08,23.61 R8.2 | 7.08,23.61 7.68,23.61 7.74,23.55
  Bottom 0.254: v7.77,23.55 7.54,23.55 7.54,20.42 10.28,17.68 46.4,17.68 47.39,16.69 63.11,16.69 63.5,17.07 78.38,17.07 81.48,20.19 v88.29,20.19
ADC2  (via drill 0.3)
  Top 0.254: U2.8 94.43,20.04 94.15,19.68 v87.65,19.68 | R20.1 R21.2 C9.1 R7.1 6.99,19.38 v7.69,19.38
  Bottom 0.254: v87.65,19.68 81.96,19.74 78.86,16.64 63.72,16.64 63.37,16.28 46.91,16.28 46.1,17.09 9.98,17.09 v7.69,19.38
AGND  (via drill 0.3)  (3 unrouted)
  Top 0.254: 25.89,12.6 25.89,13.69 C7.2 26.25,13.7 27.5,14.96 U1.45 v30.07,14.96 | 25.89,12.6 C13.2 | R25.1 R26.1 R29.1 R30.1 23.15,9.04 | C12.- 21.94,19.71 23.11,18.54 23.71,18.54 C11.2 C46.2 25.89,18.57 26.46,18.57 26.56,18.47 26.56,17.8 27.41,16.95 U1.41 30.13,16.95 v30.5,16.59 | 24.07,12.57 C8.- 24.89,12.56 | 24.89,12.56 25.86,12.56 25.89,12.6 | C16.- 24.75,12.43 24.89,12.56 | PCM5101.3 51.38,13.39 51.94,12.83 | R80.1 23.16,12.01 23.77,12.62 24.15,12.62 24.18,12.65 24.18,12.6 24.15,12.57 | C51.1 C50.1 55.67,14.74 55.67,14.17 | PCM5101.9 51.27,17.29 51.53,17.55 51.75,17.55 C47.2 v52.04,18.54 | C45.- 55.57,10.91 C22.- 55.6,11.05 56.66,12.12 56.66,13.56 56.38,13.84 55.93,13.84 55.67,14.1 55.67,14.17 | C48.1 52.26,12.94 52.55,13.23 52.55,13.54 52.85,13.84 55.34,13.84 55.67,14.17
  Top 0.406: C12.- 21.02,19.77 v20.87,19.91
  Top 0.61: v55.62,18.54 55.68,18.33 C51.1
  Bottom 0.254: v30.07,14.96 30.09,14.96 30.45,15.32 30.45,16.54 v30.5,16.59
  Bottom 0.406: 52.14,18.54 48.48,18.54 47.04,19.99 22.13,19.96 20.92,19.96 v20.87,19.91
  Bottom 0.61: v52.04,18.54 52.14,18.54 v55.62,18.54 58.4,21.22 LINE_IN.GND 59.46,30.37 59.46,34.27 61.08,35.89 61.08,38.38 60.45,39.01 LINE_OUT.GND
AMY_FOLLOWER_SCL  (via drill 0.3)
  Top 0.305: U2.5 v98.24,24.61 | v84.25,40.82 v84.24,40.81 I2C_CONTROL.1
  Bottom 0.305: v98.24,24.61 98.7,25.07 98.7,36.88 94.76,40.82 v84.25,40.82
AMY_FOLLOWER_SDA  (via drill 0.3)
  Top 0.305: U2.4 99.51,24.36 v99.51,24.51 | v86.25,41.71 I2C_CONTROL.2
  Bottom 0.305: v99.51,24.51 99.51,37.26 95.07,41.71 v86.25,41.71
AMYIN  (via drill 0.3)
  Top 0.254: U2.17 84.32,19.07 84.2,18.95 v84.2,18.06 | v38.68,15.42 37.26,15.47 U1.17
  Bottom 0.254: v84.2,18.06 83,18.06 80.13,15.19 64.36,15.19 64.23,14.99 45.36,14.99 45.05,15.37 38.73,15.37 v38.68,15.42
AMYOUT  (via drill 0.3)
  Top 0.254: U2.6 96.97,19.48 96.06,18.57 v88.82,18.57 | v45.49,16.03 44.18,16.03 PCM5101.14 | U1.10 34.82,13.26 v35.17,13.72
  Bottom 0.254: v88.82,18.57 82.67,18.57 79.9,15.8 64.16,15.8 63.85,15.42 46.07,15.42 v45.49,16.03 37.59,16.03 v35.17,13.72
BCLK  (via drill 0.3)
  Top 0.254: U1.8 33.82,15.53 34.74,16.46 U1.19 41.24,16.45 41.42,16.64 PCM5101.13 45.18,16.64 45.51,16.97 v45.51,19.3 | U2.12 89.35,21.97 v89.17,21.84
  Bottom 0.254: v89.17,21.84 80.74,21.84 77.57,18.67 62.58,18.67 62.56,18.64 62.5,18.59 61.87,17.96 48.38,17.96 47.04,19.3 v45.51,19.3
CV_OUT1
  Top 0.254: U4.1 50.17,27.05 R27.1 50.16,40.46 45.61,45.01 21.2,45.01 CV_OUT1.LEFT/TIP
CV_OUT2  (via drill 0.3)
  Top 0.254: U4.7 50.96,19.43 R10.1 50.63,19.63 v48.23,19.63
  Bottom 0.254: v48.23,19.63 39.64,28.22 39.64,30.23 29.89,39.98 CV_OUT2.LEFT/TIP
DTR  (via drill 0.3)
  Top 0.305: Q5.2 86.91,3.82 | 86.91,3.82 87.62,3.82 R48.2 | v86.91,3.2 86.91,3.82
  Bottom 0.305: HOST.11 85.49,4.62 v86.91,3.2
ENABLE
  Top 0.305: U6.4 73.08,21.07 73.76,20.4 74.38,20.4 R14.2
ENABLE1
  Top 0.305: U3.4 75.91,19.96 R23.2
GND  (via drill 0.3)  (1 unrouted)
  Top 0.203: C5.2 arc103 39.56,18.57 38.32,18.57 | 100.49,0.53 103.5,0.51 | 23.63,20.25 24.68,21.31
  Top 0.254: USB.GND2 68.63,41.53 67.23,40.13 C85.1 | U1.21 38.17,17.45 38.58,17.04 39.95,17.04 | 39.95,17.04 40.1,17.2 40.1,17.96 40.13,17.98 40.1,17.98 | 39.95,17.04 42.72,17.04 43,17.32 44.1,17.32 | 44.1,17.32 PCM5101.12 | 44.1,17.32 44.1,17.9 PCM5101.11 44.14,19 43.48,19.66 43.48,20.92 U7.4 U7.3 | BOOT.3 100.49,0.53 | 103.5,0.51 104.26,1.45 104.41,1.45 104.44,1.42 104.47,1.42 103.7,2.18 103.7,2.95 | RST.4 97.5,1.96 RST.1 | U1.26 35.3,20.4 35.3,21.59 37.59,23.88 37.59,24.18 37.61,24.18 | Y1.2 23.63,20.25 | 24.68,21.31 24.71,21.57 24.86,21.72 24.86,21.74 24.89,21.77 24.89,21.73 Y1.4 | 38.32,18.57 38.2,18.44 37.61,18.44 37.59,18.47 U1.23 | C23.1 48.78,23.61 48.69,23.52 v48.64,23.52 | C24.1 49.59,20.74 v49.02,20.17 49.04,20.17 | v84.17,7.29 84.17,7.21 84.83,6.55 85.87,6.55 86.23,6.91 86.58,6.91 86.76,7.09 | C15.2 41.13,13.41 C41.1 | PCM5101.16 43.37,14.74 42.87,15.24 41.5,15.19 41.4,15.29 | v55.98,25.2 56.51,25.2 56.59,25.15 | 59.51,25.15 59.61,25.02
  Top 0.305: 56.59,25.15 59.51,25.15
  other vias: 102,0.66 55.06,24.33 53.92,26.47 54.66,25.78 56.08,26.31 87.93,9.83 87.96,10.82 87.9,11.84 88.77,11.38 88.72,10.29 89.63,11.86 89.58,10.79 89.53,9.6 90.39,10.11 90.34,11.25 90.32,12.52 91.11,11.94 91.08,10.67 91.08,9.47 91.89,10.06 91.84,11.3 91.89,12.65 92.65,11.99 92.73,13.16 92.6,10.74 92.65,9.5 93.42,10.11 93.47,11.35 93.39,12.55 26.97,20.98 26.84,21.82 25.95,22.05 25.8,22.94 13.1,4.93 13.08,3.2 13,1.02 14.42,2.03 16.81,2.03 19.4,2.01 18.11,0.94 15.64,0.99 15.44,3.12 18.11,2.92 23.82,6.81 25.45,6.86 27.55,6.53 27.58,5.33 27.48,3.91 27.48,2.51 27.43,1.14 31.31,1.17 35.23,0.84 38.5,0.81 38.43,3 39.92,2.08 35.17,2.9 37.21,2.03 23.8,11.46 23.77,10.34 23.77,9.3 26.13,7.98 25.67,9.3 32.15,4.27 32.08,5.69 35.23,5.41 37.1,5.33 39.21,5.28 41.5,5.28 43.18,11.2 51.2,29.69 52.78,29.69 53.49,30.76 53.46,35.79 53.44,38 52.12,36.91 52.14,38.91 51.15,38.05 51.07,35.89 51.13,39.95 47.67,44.09 48.94,42.93 49.98,41.71 50.03,42.93 48.89,44.2 50.01,44.22 89.2,0.99 91.31,0.97 87.96,2.82 88.97,2.79 89.99,2.92 82.47,3.84 81.66,7.24 79.45,6.07 80.46,7.54 80.46,8.86 81.73,8.71 79.45,11.99 78.81,10.77 79.52,9.47 80.16,10.49 81.05,9.78 82.95,8.1 82.6,10.9 83.38,10.26 84.22,9.42 84.22,10.44 81.25,13.31 73.5,12.04 72.51,11.33 64.36,12.14 65.76,12.14 67.31,12.09 69.08,12.04 68.07,10.9 66.54,10.95 65.15,11.3 69.87,10.74 70.28,12.01 71.06,9.55 68.8,9.32 66.97,9.04 67.56,9.91 61.74,11.13 63.34,11.05 64.61,9.78 63.7,8.43 62.23,8.28 62.73,9.42 61.74,9.96 62.15,6.4 62.15,4.52 62.15,2.84 62.07,0.94 63.5,1.78 63.55,3.81 63.42,5.66 64.56,2.77 64.79,0.89 66.7,0.89 68.45,0.86 70.43,0.84 69.24,1.85 67.58,1.91 65.7,1.91 66.85,2.82 68.45,2.79 11.86,0.97 7.08,5.46 8.91,5.69 10.56,2.03 10.59,4.72 5.61,4.5 5.58,6.68 34.01,26.64 30.58,25.48 31.85,25.5 34.03,25.1 34.06,23.8 34.08,22.3 29.59,21.77 5.74,43.08 5.76,41.73 5.71,40.03 5.74,38.81 5.76,37.34 5.74,36.25 5.71,34.24 5.74,32.56 6.85,33.45 6.83,35.51 6.88,37.87 6.95,39.55 6.88,40.87 5.76,30.45 5.68,28.35 5.66,26.75 5.66,24.84 6.65,29.31 6.83,31.39 7.84,32.46 8,34.37 7.92,36.6 8,38.51 8.35,41.96 8.96,47.14 11.63,47.19 10.54,45.87 12.37,44.81 12.62,42.29 15.11,44.58 13.79,43.48
  pour Bottom: -5.1,60 124.9,60 124.9,-10 -5.1,-10
  pour Top: -6.1,61 125.9,61 125.9,-11 -6.1,-11
I2C_SCL  (via drill 0.3)
  Top 0.254: U7.1 39.13,20.39 U1.25 v35.82,18.78 v35.81,18.77 | U2.11 90.62,21.67 90.27,21.31 v88.31,21.31 | v12.57,18.77 8.17,14.38 v8.17,7.37
  Bottom 0.254: v8.17,7.37 8.2,7.34 I2C_HOST.1 | v88.31,21.31 81,21.31 77.72,18.03 62.68,18.03 62.17,17.53 48.08,17.53 46.83,18.77 v35.81,18.77 v12.57,18.77
I2C_SDA  (via drill 0.3)  (1 unrouted)
  Top 0.254: U7.2 40.97,19.51 | 40.97,19.51 40.41,19.07 37.25,19.07 U1.24 | U2.10 91.89,21.24 91.38,20.73 v87.68,20.73 | v13.1,18.24 8.86,13.99 v8.86,9.35 | 40.97,19.51 41.55,18.92 v41.55,18.24
  Bottom 0.254: v13.1,18.24 v41.55,18.24 46.58,18.24 47.72,17.09 62.66,17.09 63.14,17.58 78.02,17.58 78.13,17.68 | v8.86,9.35 8.87,9.34 I2C_HOST.2 | v87.68,20.73 81.2,20.73 78.02,17.55
IO0
  Top 0.305: BOOT.2 98.47,4.75 87.32,4.75 86.81,5.26 U2.27 85.89,5.88 83.94,3.94 Q5.3 82.58,2.87 R49.1
IO19  (via drill 0.3)
  Top 0.305: U2.13 v88.08,24.79 | v72.44,37.72 R45.2
  Bottom 0.305: v88.08,24.79 88.08,34.8 85.19,37.69 72.46,37.69 v72.44,37.72
IO20  (via drill 0.3)
  Top 0.305: U2.14 v86.81,24.79 | v71.39,37.41 R46.2
  Bottom 0.305: v86.81,24.79 86.81,34.62 84.78,36.65 72.16,36.65 v71.39,37.41
LIN  (via drill 0.3)
  Top 0.305: R2.2 v27.96,8.08 | v58.87,6.73 58.87,11.35 58.64,11.58 v58.47,18.54
  Bottom 0.305: v27.96,8.08 29.31,6.73 v58.87,6.73 | v58.47,18.54 60.42,20.22 60.5,26.14 62.96,28.6 LINE_IN.LEFT/TIP
LINX
  Top 0.254: U1.47 27.95,13.96 27.66,13.66 27.66,9.41 C43.+
LOUT  (via drill 0.3)
  Top 0.254: U4.8 57.68,19.62 R22.1 59.36,19.46 59.89,18.92 v60.14,18.47
  Bottom 0.305: v60.14,18.47 62.15,20.22 62.1,26.44 64.71,29.06 64.71,40.87 LINE_OUT.LEFT/TIP
LOUT_2V  (via drill 0.3)
  Top 0.254: C50.2 55.08,14.81 v54.1,14.48 R51.1
  Top 0.305: U4.10 56.18,21.97 55.88,21.67 55.88,19.28 56.48,18.67 v56.43,14.48
  Bottom 0.254: v54.1,14.48 56.36,14.53 v56.43,14.48
LRC  (via drill 0.3)  (1 unrouted)
  Top 0.254: PCM5101.15 | v34.31,10.79 U1.9 34.32,15.22 35.05,15.95 U1.18 42.79,15.96 43.45,15.29 44.04,15.29 44.09,15.34
  Top 0.305: U2.38 100.78,6.96 98.98,8.76 v88.01,8.76
  Bottom 0.254: v88.01,8.76 83.79,8.76 79.78,12.78 58.95,12.78 58.69,12.52 38.1,12.52 36.37,10.79 v34.31,10.79
MCLK  (via drill 0.3)
  Top 0.254: U2.15 83.84,21.61 83.64,21.41 v83.64,17.53 | U1.20 33.61,16.95 v31.57,14.91
  Bottom 0.254: v83.64,17.53 80.74,14.55 57.91,14.55 57.45,13.97 36.9,13.97 35.61,12.62 32.56,12.62 31.57,13.82 v31.57,14.91
MIDI_IN  (via drill 0.3)
  Top 0.254: R35.2 10.41,25.09 U15.4 12.21,25.35 14.09,23.47 v14.09,14.58 | U2.23 v84.37,11.46
  Bottom 0.254: v84.37,11.46 82.01,11.46 79.42,14.1 58.44,14.1 57.91,13.51 37.33,13.51 35.91,12.09 16.58,12.09 v14.09,14.58
MIDI_OUT
  Top 0.305: U2.22 R37.2
MPIO  (via drill 0.3)
  Top 0.254: U2.7 95.7,19.61 95.27,19.18 v88.16,19.18 | v33.27,13.77 33.32,13.57 U1.7 33.32,12.01 33.32,11.98 33.29,11.96
  Bottom 0.254: v88.16,19.18 82.32,19.18 79.37,16.23 63.93,16.2 63.55,15.82 46.63,15.85 45.92,16.56 36.06,16.56 v33.27,13.77
N$1
  Top 0.254: U1.37 28.89,22.6 C1.1
N$2
  Top 0.254: R3.1 C4.2
N$3
  Top 0.254: U1.15 38.89,14.46 C4.1
N$4
  Top 0.254: 1-10VPP.1 30.96,2.03 29.51,3.48 29.51,8.01 R2.1 29.57,9.22 C43.-
N$5
  Top 0.254: 1-10VPP.2 32.15,3.3 31.34,4.12 31.34,7.92 R1.1 31.43,8.05 C44.-
N$6
  Top 0.254: C8.+ 24.1,14.59 C7.1 25.89,14.61 26.41,14.61 27.26,15.46 U1.44
N$7
  Top 0.254: U1.43 26.8,15.96 26.54,15.7 25.92,15.7 C17.2 24.86,15.71 C6.2
N$8
  Top 0.254: C6.1 22.89,15.72 R4.1
N$13  (via drill 0.3)
  Top 0.254: R7.2 v6.98,17.6 | v7.92,29.59 10.13,29.23 15.77,34.87 15.79,34.9 16.25,35.36 27.25,35.36 29.61,33 CV_IN2.LEFT/TIP
  Bottom 0.254: v6.98,17.6 6.98,26.98 7.92,27.91 v7.92,29.59
N$15
  Top 0.305: U3.1 78.8,23.75 | 78.8,23.75 78.8,27.12 L1.P$2 | D6.A 78.8,23.74 78.8,23.75
N$16
  Top 0.305: C31.2 62.12,15.7 | 62.12,15.7 63.98,15.72 D10.A | FB1.1 62.12,19.62 62.12,15.7
N$18
  Top 0.254: U7.8 42.24,24.54 42.74,24.03 48.51,24.03 48.98,24.5 C23.2 49.41,24.51 U4.3
N$19
  Top 0.254: R5.2 6.95,27.38 7.54,27.96 10.36,28.7 14.55,32.89 CV_IN1.LEFT/TIP
N$20  (via drill 0.3)
  Top 0.254: U4.5 49.97,21.97 C24.2 49.39,21.63 v48.51,20.75 | v47.82,24.69 47.57,24.43 44.24,24.43 43.51,25.17 U7.7
  Bottom 0.254: v48.51,20.75 47.82,21.44 v47.82,24.69
N$21
  Top 0.305: L3.P$2 70.94,23.51 U6.1 68.43,22.97 D8.A 67.97,22.24 C30.1
N$22
  Top 0.254: U7.10 C42.+ | C42.+
N$23  (via drill 0.3)
  Top 0.305: D5.A D3.C v66.29,32.74 | Q1.1 81.04,32.16 | 81.04,32.16 81.04,31.67 R11.2 | D4.C 80.39,32.21 | 80.39,32.21 80.99,32.21 81.04,32.16 | v80.31,32.69 80.31,32.28 80.39,32.21
  Bottom 0.305: v66.29,32.74 v80.31,32.69
N$24  (via drill 0.3)  (1 unrouted)
  Top 0.305: C106.1 86.41,28.82 U16.3 84.83,27.76 84.55,27.48 v83.79,27.48 83.33,27.48 82.94,27.87 U16.1 | D5.C v67.97,24.23
  Bottom 0.254: v67.97,24.23 80.51,24.23 82.95,26.67
  Bottom 0.305: 82.93,26.62 v83.79,27.48
N$25
  Top 0.305: R34.1 76.87,22.39 U3.3 75.52,22.36 C32.1 R33.2
N$26
  Top 0.305: U6.3 R18.1 70.39,18.73 C29.2 70.91,17.51 R19.2
N$28
  Top 0.305: R16.2 71.84,21.83 72.03,22.02 U6.5
N$29
  Top 0.305: D10.C 64.26,20.02 C30.2 66.44,18.41 D9.A
N$31
  Top 0.254: U4.6 50.81,20.7 R10.2
  Top 0.305: R13.1 53.92,18.66 53.92,20.5 53.72,20.7 U4.6
N$32
  Top 0.305: R15.2 U3.5
N$33
  Top 0.254: U4.2 50.53,25.78 R27.2
  Top 0.305: R12.1 54.43,17.92 54.43,25.04 53.69,25.78 U4.2
N$34
  Top 0.305: R48.1 90.07,3.83 Q2.1
N$35
  Top 0.254: 1-10VPP.5 R30.2
N$36
  Top 0.254: 1-10VPP.6 R29.2
N$37
  Top 0.305: Q5.1 R9.1
N$38
  Top 0.305: USB.A5 73.1,39.83 R53.1
N$39
  Top 0.305: USB.B5 70.1,39.79 R52.1
N$40
  Top 0.254: 1-10VPP.8 24.06,2.03 R25.2
N$41
  Top 0.254: 1-10VPP.7 R26.2
N$42  (via drill 0.3)
  Top 0.305: USB.VBUS2 69.4,40.86 v69.11,40.56 68.85,40.31 FB3.1 | v74.29,40.56 74.29,41.76 USB.VBUS1
  Bottom 0.305: v69.11,40.56 v74.29,40.56
N$44  (via drill 0.3)  (2 unrouted)
  Top 0.254: 1-10VPP.3 v34.34,4.57 | R22.2 57.67,20.51 57.48,20.7 | 60.73,19.14 60.73,19.25 60.09,19.89 60.09,20.22 59.81,20.5 59.2,20.5
  Top 0.305: v60.12,4.75 60.12,17.32 60.73,17.93 60.73,19.14
  Bottom 0.305: v34.34,4.57 59.94,4.57 v60.12,4.75
N$45  (via drill 0.3)
  Top 0.254: 1-10VPP.4 34.16,5.84 34.31,5.99 v34.39,5.99
  Top 0.305: U4.13 59.57,25.78 R28.2 59.72,25.91 v61.08,25.91 | v59.2,18.47 59.38,11.81 59.56,11.63 59.56,5.36 v59.48,5.99
  Bottom 0.305: v59.2,18.47 61.13,20.07 v61.08,25.91 | v34.39,5.99 v59.48,5.99
N$48
  Top 0.254: PCM5101.18 C41.2 | C41.2 | C41.2 C2.+
N$50
  Top 0.254: PCM5101.7 52.78,15.99 R50.2
N$51
  Top 0.254: C49.2 47.46,12.76 48.74,14.05 49.97,14.05 PCM5101.4
N$52
  Top 0.254: PCM5101.2 48.72,12.74 48.36,12.37 48.36,10.81 C49.1
N$55  (via drill 0.3)
  Top 0.254: U15.2 22.32,25.47 D13.+ 28.09,26.17 v29.26,27.33 | v31.67,27.38 37.34,33.05 MIDI_IN.LEFT/TIP
  Bottom 0.254: v29.26,27.33 v31.67,27.38
N$56
  Top 0.254: R36.1 28.74,25.51 32.94,29.72 MIDI_IN.RIGHT/RING
N$57
  Top 0.254: U15.1 22.32,22.93 D13.- 23.18,24.62 R36.2
N$58  (via drill 0.3)
  Top 0.254: R37.1 v82.47,12.72
  Bottom 0.254: v82.47,12.72 88.06,12.72 89.71,14.3 89.71,34.29 79.4,44.58 65.48,44.58 64.69,45.01 43.65,45.09 MIDI_OUT.LEFT/TIP
N$59  (via drill 0.3)
  Top 0.254: R38.1 9,26.84 v9.01,26.98
  Bottom 0.254: v9.01,26.98 9.04,37.39 16.66,45.01 31.19,45.01 32.94,43.26 MIDI_OUT.RIGHT/RING
N$75
  Top 0.305: SD1.1 93.41,37.24 R39.1
N$77
  Top 0.305: SD1.8 92.52,29.54 R43.1
OUTL
  Top 0.254: PCM5101.6 52.36,15.34 R51.2
RESET  (via drill 0.3)
  Top 0.305: R47.1 C36.2 100.78,25.34 U2.3 v100.78,21.67 | Q2.3 92.13,2.88 RST.2 93.12,2.88 v93.11,2.9
  Bottom 0.305: v93.11,2.9 100.78,10.57 v100.78,21.67
RIN  (via drill 0.3)
  Top 0.305: R1.2 v32.91,7.92 | v58.31,7.32 58.31,10.97 57.96,11.33 v57.78,18.67 | v61.84,30.28 59.13,32.99 v57.93,32.99
  Bottom 0.305: v32.91,7.92 33.52,7.32 v58.31,7.32 | v57.78,18.67 59.81,20.45 59.86,26.47 61.92,28.52 v61.84,30.28 | v57.93,32.99 v57.93,33 LINE_IN.RIGHT/RING
RINX
  Top 0.254: U1.48 28.89,11.82 29.81,10.9 31.78,10.9 C44.+
ROUT
  Top 0.305: U4.14 59.47,27.05 R28.1
  Top 0.61: U4.14 55.55,27.05 55.09,27.51 55.09,29.72 57.02,31.65 57.02,34.47 54.94,36.55 LINE_OUT.RIGHT/RING
ROUT_2V
  Top 0.254: R50.1 C51.2
  Top 0.305: U4.12 56.21,24.51 54.94,23.24 54.94,15.99 C51.2
RTS  (1 unrouted)
  Top 0.254: 87.46,0.81 88.06,0.81 88.59,1.35 88.59,1.88 88.57,1.91
  Top 0.305: R9.2 Q2.2 | 87.46,0.81 71.98,0.81 HOST.3
RXD/IO44  (via drill 0.3)
  Top 0.305: HOST.7 75.36,2.52 80.34,2.52 81.28,3.45 v81.28,5.31 | v89.28,7.29 97.71,7.29 98.24,6.76 U2.36
  Bottom 0.305: v81.28,5.31 87.27,5.28 v89.28,7.29
SPDIFIN_SIGNAL  (via drill 0.3)
  Top 0.254: C1.2 28.9,24.89 30.35,26.34 32.48,26.34 33.73,27.58 37.87,27.58 40.33,30.05 44.62,30.05 v47.54,32.97
  Bottom 0.254: v47.54,32.97 51.86,32.97 SPDIF_IN.LEFT/TIP
SPDIFOUT_SIGNAL  (via drill 0.3)
  Top 0.305: R3.2 38.92,7.96 v38.91,7.95 | v57.75,7.95 57.75,10.46 57.2,11.02 v57.09,18.54
  Bottom 0.305: v38.91,7.95 v57.75,7.95
  Bottom 0.406: v57.09,18.54 57.09,18.82 59.13,20.85 59.13,26.77 60.88,28.52 60.88,34.37 62.12,35.61 62.12,39.06 60.65,40.54 56.54,40.54 55.65,39.65 53.59,39.65 51.89,41.35 SPDIF_OUT.LEFT/TIP | SPDIF_OUT.LEFT/TIP
SPI0_CS0  (via drill 0.3)
  Top 0.254: HOST.4 69.77,8.76 71.32,8.76 78.43,15.88 79.24,15.88
  Top 0.305: SD1.2 93.38,36.14 R40.1 D12.1 93.25,34.25 v93.26,34.27 | v90.93,17.8 U2.18 85.06,17.8 83.13,15.88 79.24,15.88
  Bottom 0.305: v90.93,17.8 90.93,31.93 v93.26,34.27
SPI0_MISO  (via drill 0.3)
  Top 0.305: R42.1 92.52,30.64 92.93,30.64 | 92.93,30.64 v93.21,30.64 SD1.7 | D12.6 92.93,32.21 92.93,30.64 | v93.01,13.99 U2.21 80.08,13.99 HOST.8
  Bottom 0.305: v93.01,13.99 93.01,30.44 v93.21,30.64
SPI0_MOSI  (via drill 0.3)
  Top 0.305: D12.3 v90.55,34.25 90.01,34.25 R41.1 | v90.22,16.54 U2.19 84.86,16.54 83.59,15.27 78.81,15.27 HOST.6 | v94.18,35.03 95.86,35.03 SD1.3
  Bottom 0.305: v94.18,35.03 94.15,35 91.45,35 v90.55,34.25 90.22,33.84 v90.22,16.54
SPI0_SCK  (via drill 0.3)
  Top 0.305: R44.1 91.94,31.41 v91.94,31.85 D12.5 | v92.12,15.21 92.07,15.27 U2.20 84.6,15.27 83.97,14.63 79.52,14.63 v74.14,9.25 | v94.74,32.82 SD1.5 | v76.78,9.25 75.79,8.26 HOST.10
  Bottom 0.305: v92.12,15.21 92.12,31.67 | 92.12,31.67 v91.94,31.85 | 92.12,31.67 92.12,32.16 92.81,32.84 v94.74,32.82 | v74.14,9.25 v76.78,9.25
TXD/IO43  (via drill 0.3)
  Top 0.305: HOST.9 77.24,3.17 80.13,3.17 80.51,3.56 v80.51,6.27 | v88.08,7.44 88.77,8.13 98.29,8.13 99.51,6.91 U2.37
  Bottom 0.305: v80.51,6.27 86.91,6.27 v88.08,7.44
USB_D+
  Top 0.305: R46.1 71.1,39.83 USB.B6 71.1,42.68 71.32,42.9 71.93,42.9 72.1,42.73 USB.A6
USB_D-
  Top 0.305: USB.B7 72.6,40.72 | 72.6,40.72 72.6,39.67 R45.1 | USB.A7 71.6,40.87 71.75,40.72 72.6,40.72
VNEG
  Top 0.254: PCM5101.5 51.31,14.69 C48.2
VPWR
  Top 0.305: D2.C D14.C 71.85,35.28 70.94,34.37 70.94,32.21 | 70.94,32.21 L3.P$1 73.44,29.16 73.52,29.07 73.78,28.81 | D1.C 70.94,32.21 | 73.78,28.81 L1.P$1 | R14.1 R23.1 74.05,21.27 73.78,21.54 73.78,28.81
XTI
  Top 0.254: U1.39 27.89,17.95 27.66,18.19 27.66,22.02 25.85,23.82 24.18,23.82 23.97,23.62 23.97,23.05 C18.2 23.96,22 Y1.1
XTO
  Top 0.254: U1.40 27.63,17.45 27.12,17.96 27.12,18.96 C19.2 24.87,20.05 Y1.3

## Text on the board
tPlace: + | + | + | + | + | + | + | + | + | + | + | +
bPlace: OUT1 | OUT | OUT | OUT | MIDIIN/ | SPDIFIN/ | LINEIN/ | CVIN/ | OUT2 | CVIN/ | AmyBoard | V1.0
Measures: Units: Inches | Units: Inches